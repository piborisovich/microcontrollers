# IAR project Termometer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1QI Milandr MDR32F1QI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 36
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; src; ..\..\Libraries\SPL\MDR32FxQI\inc; ..\..\Libraries\CMSIS\MDR32FxQI\CoreSupport\CM1; ..\..\Libraries\CMSIS\MDR32FxQI\DeviceSupport\MDR32F1QI\inc; ..\..\Libraries\CMSIS\MDR32FxQI\DeviceSupport\MDR32F1QI\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Termometer.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MDR32FxQI_config.h
  group Driver
    ../../Libraries/SPL/MDR32FxQI/src/: MDR32FxQI_bkp.c MDR32FxQI_eeprom.c MDR32FxQI_port.c MDR32FxQI_rst_clk.c MDR32FxQI_timer.c
    ../../Libraries/CMSIS/MDR32FxQI/DeviceSupport/MDR32F1QI/startup/: system_MDR32F1QI.c
  group src
    src/: lcd.c lcd.h lcd_buffer.c lcd_buffer.h main.c timeout.c timeout.h
  group Startup
    ../../Libraries/CMSIS/MDR32FxQI/DeviceSupport/MDR32F1QI/startup/iar/: startup_MDR32F1QI.S
