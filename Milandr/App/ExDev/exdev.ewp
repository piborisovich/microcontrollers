# IAR project exdev.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F9Q2I Milandr MDR32F9Q2I
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Libraries\CMSIS\MDR32FxQI\CoreSupport\CM3; ..\..\Libraries\SPL\MDR32FxQI\inc; ..\..\Libraries\SPL\MDR32FxQI\src; ..\..\Libraries\CMSIS\MDR32FxQI\DeviceSupport\MDR32F9Q2I\inc; ..\..\Libraries\CMSIS\MDR32FxQI\DeviceSupport\MDR32F9Q2I\startup; ..\..\Libraries\CMSIS\MDR32FxQI\DeviceSupport\MDR32F9Q2I\startup\iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: exdev.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MDR32FxQI_config.h
  group Driver
    ../../Libraries/SPL/MDR32FxQI/src/: MDR32FxQI_bkp.c MDR32FxQI_eeprom.c MDR32FxQI_port.c MDR32FxQI_rst_clk.c MDR32FxQI_timer.c MDR32FxQI_uart.c
  group src
    src/: main.c
  group Startup
    ../../Libraries/CMSIS/MDR32FxQI/DeviceSupport/MDR32F9Q2I/startup/iar/: startup_MDR32F9Q2I.S
    ../../Libraries/CMSIS/MDR32FxQI/DeviceSupport/MDR32F9Q2I/startup/: system_MDR32F9Q2I.c system_MDR32F9Q2I.h
